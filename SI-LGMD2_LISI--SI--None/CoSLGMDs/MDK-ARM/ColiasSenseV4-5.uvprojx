# Keil uVision project ColiasSenseV4-5.uvprojx, settings and files
target ColiasSenseV4-CHENGS5-SSD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ColiasSenseV4 +hex
  c flags: Optim=2 oTime=1 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\SenseBoard;..\SenseBoard\Hardware\Inc;..\SenseBoard\Models\Inc;..\User\Inc;..\ThirdParty
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\ColiasSenseV4.sct
  link misc: --diag_suppress=L6329
  group User
    ../User/Src/: main.c stm32f4xx_it.c misc.c
    ../SenseBoard/: CCMRAM_DEF.c
  group S_Hardware
    ../SenseBoard/: coliasSense_board.c delay.c
    ../SenseBoard/Hardware/Src/: coliasSense_Camera.c coliasSense_CLED.c coliasSense_interfaces.c coliasSense_UART.c coliasSense_BIO.c coliasSence_Motion.c coliasSense_Exbd.c coliasSense_MPU9250.c
  group S_Models
    ../SenseBoard/: RegAccess.c
    ../SenseBoard/Models/Src/: user_terminal.c coliasSense_LGMD.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DCMI 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:I2S 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:RNG 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:STM32Cube HAL:UART 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3
